# Keil uVision project fly_demo.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: fly_demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\USER;..\FWLIB\inc;C:\Keil_v5\ARM\PACK\Keil\STM32F1xx_DFP\2.3.0\Device\Include;..\OS\core\include;..\OS\portable
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTCODE
    ../CMSIS/startcode/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/: system_stm32f10x.c core_cm3.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group OS/port
    ../OS/portable/: port.c heap_4.c
  group OS/core
    ../OS/core/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group USER
    ../USER/: main.c user.c isr.c self_stm32f10x.c stm32f10x_it.c FreeRTOSConfig.h
  group BSP
    ../USER/BSP/: bsp_usart.c bsp_spi.c bsp_i2c.c
  group HARDWARE
    ../USER/HARDWARE/nrf24/: nrf24l01.c
    ../USER/HARDWARE/oled/: oled.c
    ../USER/HARDWARE/mpu9250/: mpu9250.c
  group SOFTWARE
    ../USER/SOFTWARE/vofa/: vofa_p.c
